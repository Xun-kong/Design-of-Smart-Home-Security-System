# Keil uVision project Design of Smart Home Security System.uvprojx, settings and files
target Design of Smart Home Security System (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Design of Smart Home Security System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: .\Lib\inc;.\System;.\User;.\public
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ASM
    ./ASM/: startup_stm32f10x_md.s
  group User
    ./User/: main.c stm32f10x_it.c
  group Lib
    ./Lib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group public
    ./public/: PWM.c OLED.c MyI2C.c gpioinit.c delay.c TIMER.c KEY.c DHT11.c mq2.c adcx.c USART.c USART.h
